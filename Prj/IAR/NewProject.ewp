# IAR project NewProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\App\inc; ..\..\App\src; ..\..\Board\inc; ..\..\Board\src; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Chip\src; ..\..\Chip\src\IAR; ..\..\Lib\CMSIS\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NewProject.srec
  ILINK.IlinkOutputFile: NewProject.out
  ILINK.IlinkIcfFile: ConfigFiles\vcan_RAM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App/src
    ../../App/src/: main.c
  group Chip/inc
    ../../Chip/inc/: common.h misc.h vectors.h
  group Chip/inc/IAR
    ../../Chip/inc/IAR/: system_MK60DZ10.h
  group Chip/inc/Kinetis
    ../../Chip/inc/kinetis/: MK60DZ10.h
  group Chip/src
    ../../Chip/src/: misc.c vectors.c
  group Chip/src/IAR
    ../../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
